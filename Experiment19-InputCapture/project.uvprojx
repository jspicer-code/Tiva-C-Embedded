# Keil uVision project project.uvprojx, settings and files
target TM4C1294 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG
  c include: .\startup_TM4C1294;.\hal;.\utilities;.\drivers
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group hal
    ./hal/: HAL.h HAL_GPIO.c HAL_GPIO.h HAL_NVIC.c HAL_NVIC.h HAL_PLL.c HAL_PLL.h HAL_SysTick.c HAL_SysTick.h HAL_SPI.c HAL_SPI.h HAL_Timer.c HAL_Timer.h
  group startup_TM4C1294
    ./startup_TM4C1294/: HAL_Config.h main.c startup_rvmdk.S
    ./hal/: tm4c1294ncpdt.h
  group startup_TM4C123
    ./startup_TM4C123/: HAL_Config.h main.c startup_rvmdk.S
    ./hal/: tm4c123gh6pm.h
  group source
    ./: Device.c Device.h
  group drivers
    ./drivers/: LCD.c LCD.h LCD_Raw.c LCD_Raw.h Switch.c Switch.h CaptureTimer.c CaptureTimer.h
  group utilities
    ./utilities/: Strings.c Strings.h
target TM4C123 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG
  c include: .\startup_TM4C123;.\hal;.\utilities;.\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
