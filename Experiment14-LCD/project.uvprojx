# Keil uVision project project.uvprojx, settings and files
target project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin --output .\rvmdk\project.bin .\rvmdk\project.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..\..;hal;drivers;utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: project.sct
  link misc: --entry Reset_Handler
  group startup
    ./: startup_rvmdk.S project.c
  group hal
    ./hal/: HAL.h HAL_GPIO.c HAL_GPIO.h HAL_NVIC.c HAL_NVIC.h HAL_PLL.c HAL_PLL.h HAL_Timer.c HAL_Timer.h HAL_SysTick.c HAL_SysTick.h tm4c123gh6pm.h
  group drivers
    ./drivers/: Switch5Position.c Switch5Position.h LCD_Raw.c LCD_Raw.h LCD.c LCD.h
  group utilities
    ./utilities/: Strings.c Strings.h
software components: CMSIS:CORE 5.0.1
