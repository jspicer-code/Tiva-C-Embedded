# Keil uVision project project.uvprojx, settings and files
target project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin --output .\rvmdk\project.bin .\rvmdk\project.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..\..;.\driverlib;.\src;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: project.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S project.c project.h Display.c Display.h
  group Libraries
    ./inc/: driverlib.lib
  group Documentation
    ./: README.txt
  group src
    ./src/: GPIO_HAL.c GPIO_HAL.h PLL_HAL.c PLL_HAL.h HAL.h SysTick_HAL.c SysTick_HAL.h UART_HAL.c UART_HAL.h ADC_HAL.c ADC_HAL.h PWM_HAL.c PWM_HAL.h Timer_HAL.h Timer_HAL.c Utilities.h Utilities.c Thermistor.c Thermistor.h SPI_HAL.c SPI_HAL.h
software components: CMSIS:CORE 5.0.1
